## qsdk/package/qtec/filecrypt/src/Kconfig
```kconfig
config filecrypt
　tristate "Just a example"
　　default n
　　help
　　　This is a example, for debugging kernel model.
　　　If unsure, say N.
```
